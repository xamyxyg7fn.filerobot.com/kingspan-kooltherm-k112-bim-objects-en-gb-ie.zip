Properties of the parts of a building model (IFC4X3), part 2 of 2

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-80
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-80; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-80mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 80; Thickness: 80mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.80mm.BIM-1056.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-80; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-80; Type Id: 308062
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.2304 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-90
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-90 90 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 90 mm
Type - Dimensions - Length: 2400mm; Thickness: 90mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.90mm.BIM-1057.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-90mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-90; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.211111 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.73684 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.211111 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-90
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-90
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-90; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-90mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 90; Thickness: 90mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.90mm.BIM-1057.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-90; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-90; Type Id: 308123
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.2592 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-25
Identity - Class: Generic
Thermal - Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(7); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Density: 0 kg/m3; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; Permeability: 0 s/m; Reflectivity: 0; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-25mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Color: 8820953; Glow: no; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-25; Shininess: 64; Smoothness: 50; Transparency: 0

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-40
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(8); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-40mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-40; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-50
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(9); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-50mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-50; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-60
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(10); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-60mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-60; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-70
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(11); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-70mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-70; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-75
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(12); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-75mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-75; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-80
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(13); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-80mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-80; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-90
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(14); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-90mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-90; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-100
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(1); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-100mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-100; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-110
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(2); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-110mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-110; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-120
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(3); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-120mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-120; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-130
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(4); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-130mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-130; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-140
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(5); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-140mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-140; Shininess: 64; Smoothness: 50

# Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-150
Identity - Class: Generic
Thermal - Density: 0 kg/m3; Permeability: 0 s/m; Reflectivity: 0; Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard(6); Description: Phenolic Insulation for timber and steel framing systems.; Keywords: :Insulation: Phenolic: Rigid Insulation; Type: Solid; Source: Kingspan Insulation Ltd; Source URL: https://www.kingspan.com/gb/en/products/insulation-boards/; Emissivity: 0.01; Behavior: Isotropic; TransmitsLight: no; ElectricalResistivity: 0 kg*m3/s3/A2
Pset_MaterialCommon - Porosity: 0.001
Pset_MaterialThermal - SpecificHeatCapacity: 1880 m2/K/s2; ThermalConductivity: 0.019
Other - Category: Materials
Identity Data - Comments: n/a; Cost: 0; Description: Phenolic Insulation for timber and steel framing systems.; Manufacturer: Kingspan Insulation Ltd; Model: K112-150mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/
Materials and Finishes - Glow: no; Transparency: 0; Color: 8820953; Name: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-150; Shininess: 64; Smoothness: 50
