Properties of the parts of a building model (IFC4X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: 80f80677-6a0b-4357-9c17-819a2ae6752f, NumberOfSaves: 4], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: 01K112-KSI-XX-ZZ-M3-Z-0001.ifc
Time: 2025-06-11T13:53:48+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Kingspan Kooltherm® K112

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Pset_SpaceCommon - Reference: Project Information; IsExternal: no
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K112; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no; sets with these values: 2
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Project Address: Enter address here; Project Name: Kingspan Kooltherm® K112; Project Number: Project Number
Identity Data - Author: CM; Organization Name: Kingspan Insulation Ltd

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Pset_BuildingStoreyCommon - Reference: Level:Circle Head - Project Datum
Pset_SpaceCommon - IsExternal: no; Reference: Level:Circle Head - Project Datum
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcBuildingElementProxy: Generic Models : Model Text : 600mm KI_CenturyGothic (14)
In: Level 0
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: 600mm KI_CenturyGothic
Type - Text - Bold: no; Italic: no; Text Font: Century Gothic; Text Size: 600 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Text:600mm KI_CenturyGothic
Pset_EnvironmentalImpactIndicators - Reference: Model Text:600mm KI_CenturyGothic
Other - Family: Model Text; Family and Type: Model Text: 600mm KI_CenturyGothic; Type: 600mm KI_CenturyGothic; Type Id: 305799
Constraints - Work Plane: Level : Level 0
Dimensions - Depth: 150 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Phasing - Phase Created: New Construction
Name (Generic Models : Model Text :...) | Text
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 25mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 40mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 50mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 60mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 70mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 75mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 80mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 90mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 100mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 110mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 120mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 130mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 140mm
 600mm KI_CenturyGothic | Kingspan Kooltherm K112 - 150mm

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-100
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-100 100 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 100 mm
Type - Dimensions - Length: 2400mm; Thickness: 100mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.100mm.BIM-1058.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-100mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-100; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.19 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 5.26316 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.19 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-100
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-100
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-100; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-100mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 100; Thickness: 100mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.100mm.BIM-1058.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-100; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-100; Type Id: 308184
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.288 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-110
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-110 110 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 110 mm
Type - Dimensions - Length: 2400mm; Thickness: 110mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.110mm.BIM-1059.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-110mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-110; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.172727 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 5.78947 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.172727 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-110
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-110
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-110; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-110mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 110; Thickness: 110mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.110mm.BIM-1059.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-110; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-110; Type Id: 308245
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.3168 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-120
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-120 120 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 120 mm
Type - Dimensions - Length: 2400mm; Thickness: 120mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.120mm.BIM-1060.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-120mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-120; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.158333 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 6.31579 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.158333 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-120
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-120
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-120; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-120mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 120; Thickness: 120mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.120mm.BIM-1060.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-120; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-120; Type Id: 308306
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.3456 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-130
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-130 130 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 130 mm
Type - Dimensions - Length: 2400mm; Thickness: 130mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.130mm.BIM-1061.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-130mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-130; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.146154 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 6.84211 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.146154 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-130
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-130
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-130; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-130mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 130; Thickness: 130mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.130mm.BIM-1061.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-130; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-130; Type Id: 308367
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.3744 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-140
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-140 140 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 140 mm
Type - Dimensions - Length: 2400mm; Thickness: 140mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.140mm.BIM-1062.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-140mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-140; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.135714 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 7.36842 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.135714 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-140
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-140
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-140; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-140mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 140; Thickness: 140mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.140mm.BIM-1062.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-140; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-140; Type Id: 308428
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.4032 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-150
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-150 150 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 150 mm
Type - Dimensions - Length: 2400mm; Thickness: 150mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.150mm.BIM-1063.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-150mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-150; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.126667 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 7.89474 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.126667 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-150
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-150
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-150; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-150mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 150; Thickness: 150mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.150mm.BIM-1063.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-150; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-150; Type Id: 308485
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.432 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-25
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-25 25 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Width: 25 mm; Wrapping at Inserts: Both
Type - Dimensions - Length: 2400mm; Thickness: 25mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Color: 12632256; Coarse Scale Fill Pattern: <Solid fill>
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.25mm.BIM-1050.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-25mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-25; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Heat Transfer Coefficient (U): 0.76 kg/K/s3; Roughness: 3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 1.31579 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.76 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-25
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-25
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-25; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-25mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 25; Thickness: 25mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.25mm.BIM-1050.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-25; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-25; Type Id: 307514
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.072 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-40
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-40 40 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 40 mm
Type - Dimensions - Length: 2400mm; Thickness: 40mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.40mm.BIM-1051.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-40mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-40; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.475 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 2.10526 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.475 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-40
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-40
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-40; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-40mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 40; Thickness: 40mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.40mm.BIM-1051.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-40; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-40; Type Id: 307757
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.1152 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-50
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-50 50 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 50 mm
Type - Dimensions - Length: 2400mm; Thickness: 50mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.50mm.BIM-1052.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-50mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-50; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.38 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 2.63158 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.38 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-50
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-50
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-50; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-50mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 50; Thickness: 50mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.50mm.BIM-1052.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-50; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-50; Type Id: 307818
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.144 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-60
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-60 60 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 60 mm
Type - Dimensions - Length: 2400mm; Thickness: 60mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.60mm.BIM-1053.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-60mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-60; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.316667 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.15789 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.316667 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-60
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-60
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-60; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-60mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 60; Thickness: 60mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.60mm.BIM-1053.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-60; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-60; Type Id: 307879
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.1728 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-70
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-70 70 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 70 mm
Type - Dimensions - Length: 2400mm; Thickness: 70mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.70mm.BIM-1054.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-70mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-70; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.271429 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.68421 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.271429 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-70
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-70
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-70; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-70mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 70; Thickness: 70mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.70mm.BIM-1054.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-70; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-70; Type Id: 307940
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.2016 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-75
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-75 75 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 75 mm
Type - Dimensions - Length: 2400mm; Thickness: 75mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.75mm.BIM-1055.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-75mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-75; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.253333 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 3.94737 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.253333 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-75
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-75
Wall Schedule - Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-75; Version: 1; Export Type to IFC As: IfcCoveringType; Type IFC Predefined Type: INSULATION; ClassificationSystem: Uniclass; ClassificationCode: Pr_25_71_63_59; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Model: K112; Manufacturer: Kingspan Insulation Ltd; Type Comments: K112-75mm; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Description: Phenolic insulation for timber and steel framing systems.; Assembly Code: n/a; Type Mark: n/a; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; Length: 1200; Width: 75; Thickness: 75mm; ThermalConductivity: 0.019 (W/mK); InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.75mm.BIM-1055.V1.pdf; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.
Other - Family: Basic Wall; Family and Type: Basic Wall: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-75; Type: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-75; Type Id: 308001
Constraints - Base Constraint: Level 0; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 2400 mm
Dimensions - Area: 2.88 m2; Length: 1200 mm; Volume: 0.216 m3
Phasing - Phase Created: New Construction
Structural - Structural: no; Structural Usage: Non-bearing
Cross-Section Definition - Cross-Section: Vertical

# IfcCovering: Walls : Basic Wall : KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-80
In: Level 0
Type - PredefinedType: INSULATION; Material: KingspanInsulation01GB_Insulation_Kooltherm-K112-FramingBoard-80 80 mm
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Construction - Function: Interior; Wrapping at Inserts: Both; Width: 80 mm
Type - Dimensions - Length: 2400mm; Thickness: 80mm; Width: 1200mm
Type - Graphics - Coarse Scale Fill Pattern: <Solid fill>; Coarse Scale Fill Color: 12632256
Type - Identity Data - Assembly Code: n/a; ClassificationCode: Pr_25_71_63_59; ClassificationSystem: Uniclass; ClassificationTitle: Phenolic foam boards; ClassificationVersion: 01/04/2023; Description: Phenolic insulation for timber and steel framing systems.; Fire Rating: To BS EN 13501-1: 2018, Euroclass RtF F; HealthAndSafetyInformation: https://www.kingspan.com/content/dam/kingspan/kil/products/general-gb-and-ireland/kingspan-kooltherm-safety-information-en-gb-ie.pdf; InstallationGuidance: https://www.kingspan.com/content/dam/kingspan/kil/products/kooltherm-k112-framing-board/kingspan-kooltherm-k112-brochure-en-gb-ie.pdf; Manufacturer: Kingspan Insulation Ltd; ManufacturingFacility: This product is manufactured at Kingspan's Pembridge, Herefordshire manufacturing facility.; Model: K112; ProductDataSheet: https://ks-kentico-prod-cdn-endpoint.azureedge.net/bimstorage/K112.80mm.BIM-1056.V1.pdf; ThermalConductivity: 0.019 (W/mK); Type Comments: K112-80mm; Type Mark: n/a; Type Name: KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-80; URL: https://www.kingspan.com/gb/en/products/insulation-boards/wall-insulation-boards/kooltherm-k112-framing-board/; Version: 1
Type - Analytical Properties - Absorptance: 0.7; Roughness: 3; Heat Transfer Coefficient (U): 0.2375 kg/K/s3; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 4.21053 s3*K/kg
Type - Pset_CoveringCommon - ThermalTransmittance: 0.2375 kg/K/s3; FireRating: To BS EN 13501-1: 2018, Euroclass RtF F
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kingspan Insulation Ltd
Classification: Pr_25_71_63_59 (Default Classification); n/a (Uniformat)
Pset_CoveringCommon - IsExternal: no; Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-80
Pset_EnvironmentalImpactIndicators - Reference: Basic Wall:KingspanInsulation_Insulation_Kooltherm-K112-FramingBoard-80
